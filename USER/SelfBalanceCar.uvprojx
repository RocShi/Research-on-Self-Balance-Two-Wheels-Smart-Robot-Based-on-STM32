# Keil uVision project SelfBalanceCar.uvprojx, settings and files
target SelfBalanceCar (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SelfBalanceCar +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\HARDWARE\LED;..\HARDWARE\Key;..\HARDWARE\LCD;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050\IIC;..\HARDWARE\MPU6050\MPU6050;..\HARDWARE\MPU6050\DataReport;..\HARDWARE\Motor\Motor;..\HARDWARE\Motor\Encoder;..\HARDWARE\Motor\InputCapture;..\HARDWARE\PID;..\SYSTEM\delay;..\SYSTEM\usart;..\SYSTEM\sys;..\STM32F10x_StdPeriph_Lib\inc;..\USMART
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/Key/: Key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/MPU6050/MPU6050/: MPU6050.c
    ../HARDWARE/MPU6050/IIC/: IIC.c
    ../HARDWARE/MPU6050/DataReport/: DataReport.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/Motor/Motor/: Motor.c
    ../HARDWARE/Motor/Encoder/: Encoder.c
    ../HARDWARE/PID/: PID.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group STM32F10x_StdPeriph_Lib
    ../STM32F10x_StdPeriph_Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
